## package/uuid/Config.in
```kconfig
config BR2_PACKAGE_UUID
	bool"uuid"
	help
	  The OSSP UUID generator.

	  http://www.ossp.org/pkg/lib/uuid/
```
